options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: fft_xcorr_opencl_uhd2
    output_language: python
    realtime_scheduling: '1'
    title: 2-Channel USRP Correlator at 30 MSPS
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    type: real
    value: 95.7e6
  states: {}
- name: chans
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: delay_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: Correcting Lag [0,1]
    type: int
    value: delay_0
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: fm_sample
  id: variable
  parameters:
    value: int(samp_rate/stage1_decimation)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '32'
  states: {}
- name: lock_output
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 1,1,1,1
    label: Lock Correlator Lag
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: stage1_decimation
  id: variable
  parameters:
    value: int(samp_rate/500e3)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: int(samp_rate/stage1_decimation)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: delay_0
    type: complex
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '200'
    type: float
    vlen: chans
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: clenabled_clxcorrelate_fft_vcf_0
  id: clenabled_clxcorrelate_fft_vcf
  parameters:
    affinity: '1'
    deviceId: '0'
    devices: '1'
    num_inputs: '2'
    openCLPlatform: '1'
    platformId: '0'
    vec_len: chans
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: lfast_low_pass_filter_0_0_0
  id: lfast_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: filter_cutoff
    decim: stage1_decimation
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: filter_cutoff*.1
    win: firdes.WIN_HAMMING
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '10'
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}
- name: logpwrfft_x_0_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '10'
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 3,0,1,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-80'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    color2: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 4,0,1,2
    label1: Ref Signal
    label2: Correlated
    max: '-10'
    min: '-60'
    name: Max Power
    nconnections: '2'
    type: float
    update_time: '0.20'
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 4,2,1,2
    label1: '""'
    max: '10'
    min: '-10'
    name: '"Improvement Over Reference"'
    type: float
    update_time: '0.20'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,1,4
    label1: Blockwise
    showports: 'True'
    update_time: '0.20'
    vlen: chans
    x_start: '-chans/2'
    x_step: '1.0'
    ymax: '10.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 3,2,1,2
    int_max: '-10'
    int_min: '-80'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_sample/10000)
    interp: int(audio_rate/1e3)
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '0'
    ant0: RX2
    ant1: RX2
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_args: '"num_recv_frames=128"'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    otw: sc8
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xcorrelate_VectorMaxIndexToVar_0
  id: xcorrelate_VectorMaxIndexToVar
  parameters:
    lock: lock_output
    minCorrScore: '5'
    target: delay_0
    vec_len: chans
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_xx_0, '0', lfast_low_pass_filter_0_0_0, '0']
- [blocks_add_xx_0, '0', logpwrfft_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_delay_1, '0', blocks_add_xx_0, '1']
- [blocks_keep_one_in_n_1, '0', xcorrelate_VectorMaxIndexToVar_0, '0']
- [blocks_max_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_max_xx_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_max_xx_0_0, '0', qtgui_number_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [clenabled_clxcorrelate_fft_vcf_0, '0', blocks_keep_one_in_n_1, '0']
- [clenabled_clxcorrelate_fft_vcf_0, '0', qtgui_vector_sink_f_0, '0']
- [fft_vxx_0, '0', clenabled_clxcorrelate_fft_vcf_0, '0']
- [fft_vxx_0_0, '0', clenabled_clxcorrelate_fft_vcf_0, '1']
- [lfast_low_pass_filter_0_0_0, '0', analog_wfm_rcv_0, '0']
- [logpwrfft_x_0, '0', blocks_max_xx_0, '0']
- [logpwrfft_x_0_0, '0', blocks_max_xx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_add_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', logpwrfft_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_delay_1, '0']
- [uhd_usrp_source_0, '1', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
