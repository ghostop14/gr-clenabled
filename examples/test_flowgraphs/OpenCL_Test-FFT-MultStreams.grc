options:
  parameters:
    generate_options: qt_gui
    id: test_openclfft_multstreams
    output_language: python
  states: {}

blocks:
- name: fftsize
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 500e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: clenabled_clFFT_0
  id: clenabled_clFFT
  parameters:
    deviceId: '0'
    devices: '1'
    fft_dir: '-1'
    fft_size: '1024'
    num_streams: '2'
    openCLPlatform: '1'
    platformId: '0'
    setDebug: '0'
    shift: 'True'
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_1_0_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_3
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: note_0
  id: note
  parameters:
    note: The clFFT team said the number won't be an EXACT match for the native implementation due to variations in the math.  However the percentage difference should be irrelevant.
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: CPU
    label2: '''OpenCL'''
    label3: '''Stream 2'''
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '60'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_1, '0', clenabled_clFFT_0, '0']
- [blocks_stream_to_vector_1, '0', clenabled_clFFT_0, '1']
- [blocks_stream_to_vector_1, '0', fft_vxx_3, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_freq_sink_x_0, '2']
- [clenabled_clFFT_0, '0', fft_vxx_1_0, '0']
- [clenabled_clFFT_0, '1', fft_vxx_1_0_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_1_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_1_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [fft_vxx_3, '0', fft_vxx_1, '0']

metadata:
  file_format: 1
