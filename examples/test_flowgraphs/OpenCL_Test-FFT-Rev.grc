options:
  parameters:
    generate_options: qt_gui
    id: test_openclfft
    output_language: python
  states: {}

blocks:
- name: fftsize
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: clenabled_clFFT_0
  id: clenabled_clFFT
  parameters:
    deviceId: '0'
    devices: '1'
    fft_dir: '1'
    fft_size: fftsize
    openCLPlatform: '4'
    platformId: '0'
    setDebug: '0'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: note_0
  id: note
  parameters:
    note: The clFFT team said the number won't be an EXACT match for the native implementation due to variations in the math.  However the percentage difference should be irrelevant.
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: GNURadio
    label2: OpenCL
    nconnections: '2'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '30'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [clenabled_clFFT_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0, '0', clenabled_clFFT_0, '0']
- [fft_vxx_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
