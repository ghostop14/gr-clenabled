<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_openclfilter</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>blackman_harris_taps</value></param>
<param><key>value</key><value>[-3.2418572004644375e-07, 2.9645261551750995e-22, 1.365043885925843e-06, -1.7235086033906555e-06, -3.092606220889138e-06, 8.226855243265163e-06, -1.4439786930487325e-19, -1.8900078430306166e-05, 1.6774383766460232e-05, 2.3477739887312055e-05, -5.205564229981974e-05, 5.053303230753559e-19, 9.284893894800916e-05, -7.500263745896518e-05, -9.68268359429203e-05, 0.00020000168296974152, -7.809999461348047e-19, -0.0003163323854096234, 0.00024259470228571445, 0.00029860332142561674, -0.0005902359844185412, -7.385140887177029e-19, 0.0008628772338852286, -0.0006387289613485336, -0.000760603928938508, 0.0014575644163414836, -3.980784364034907e-18, -0.0020140595734119415, 0.0014531497145071626, 0.0016892895800992846, -0.003164999419823289, 2.069276012979389e-17, 0.004198289476335049, -0.0029739763122051954, -0.0033990165684372187, 0.006269691977649927, -1.1019450311886444e-17, -0.008095943368971348, 0.005671459715813398, 0.006421024911105633, -0.011754143051803112, 1.5408143078570238e-17, 0.015044945292174816, -0.010533600114285946, -0.011956811882555485, 0.022028032690286636, -1.9464085900242325e-17, -0.028992634266614914, 0.020799905061721802, 0.02443608082830906, -0.04724164679646492, 2.2345056712091014e-17, 0.07350441813468933, -0.061350367963314056, -0.09286905825138092, 0.30217936635017395, 0.600000262260437, 0.30217936635017395, -0.09286906570196152, -0.061350367963314056, 0.07350441813468933, 2.2345056712091014e-17, -0.04724165052175522, 0.02443608269095421, 0.020799905061721802, -0.028992637991905212, -1.9464082591519875e-17, 0.022028028964996338, -0.011956813745200634, -0.01053360104560852, 0.01504494622349739, 1.5408143078570238e-17, -0.011754140257835388, 0.0064210230484604836, 0.005671461578458548, -0.008095947094261646, -1.1019451139067056e-17, 0.006269693840295076, -0.003399017732590437, -0.002973976545035839, 0.004198289941996336, 2.0692761784155116e-17, -0.0031649998854845762, 0.0016892898129299283, 0.001453149481676519, -0.002014059340581298, -3.980783536854294e-18, 0.0014575644163414836, -0.0007606038707308471, -0.0006387287867255509, 0.0008628768846392632, -7.38513726826185e-19, -0.0005902356933802366, 0.00029860317590646446, 0.0002425947750452906, -0.0003163328510709107, -7.810000495323813e-19, 0.0002000019740080461, -9.682697418611497e-05, -7.50027465983294e-05, 9.2848960775882e-05, 5.05330529870509e-19, -5.2055769629077986e-05, 2.347772169741802e-05, 1.677440741332248e-05, -1.889990562631283e-05, -1.443980244012381e-19, 8.226688805734739e-06, -3.092666702286806e-06, -1.723544755805051e-06, 1.364882109555765e-06, 2.9648949634255084e-22, -3.2418572004644375e-07]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10.7622e6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/opt/sdr/gnuradio/gnuradio_recordings/atsc/atsctest.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>clenabled_cltapfirfilter</key>
<param><key>id</key><value>clenabled_cltapfirfilter_0</value></param>
<param><key>setDebug</key><value>0</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>use_time</key><value>False</value></param>
<param><key>devices</key><value>1</value></param>
<param><key>openCLPlatform</key><value>4</value></param>
<param><key>platformId</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>blackman_harris_taps</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>blackman_harris_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>label1</key><value>Raw</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>GNURadio</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label3</key><value>OpenCL</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>clenabled_cltapfirfilter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>clenabled_cltapfirfilter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
