options:
  parameters:
    generate_options: qt_gui
    id: test_openclfilter
    output_language: python
  states: {}

blocks:
- name: cutoff_freq
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10.7622e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/sdr/gnuradio/gnuradio_recordings/atsc/atsctest.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: clenabled_clLowPassFilter_0
  id: clenabled_clLowPassFilter
  parameters:
    beta: '6.76'
    cutoff_freq: cutoff_freq
    decimation: '1'
    deviceId: '0'
    devices: '1'
    gain: '1'
    openCLPlatform: '4'
    platformId: '0'
    samp_rate: samp_rate
    setDebug: '0'
    use_time: 'True'
    width: cutoff_freq*0.2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: cutoff_freq*.2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"green"'
    color2: '"blue"'
    color3: '"red"'
    fc: 593e6
    fftsize: '1024'
    label1: Raw
    label2: GNURadio
    label3: OpenCL
    name: '"Filtered Signal"'
    nconnections: '3'
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', clenabled_clLowPassFilter_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [clenabled_clLowPassFilter_0, '0', qtgui_freq_sink_x_0, '2']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
