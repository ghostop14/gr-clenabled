options:
  parameters:
    generate_options: qt_gui
    id: test_opencl
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10.7622e6
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/sdr/gnuradio/gnuradio_recordings/atsc/atsctest.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: clenabled_clLog10_0
  id: clenabled_clLog10
  parameters:
    deviceId: '0'
    devices: '1'
    k_val: '0'
    n_val: '20'
    openCLPlatform: '4'
    platformId: '0'
    setDebug: '0'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.3'
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 0,2,7,1
    label1: ' Native'
    label2: OpenCL Log10
    max: '50'
    min: '0'
    name: Log10
    nconnections: '2'
    type: float
    unit1: dB
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: GNURadio
    label2: CLEnabled
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_abs_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_abs_xx_1, '0', qtgui_number_sink_0, '1']
- [blocks_abs_xx_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_abs_xx_0, '0']
- [blocks_rms_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_rms_xx_0, '0', clenabled_clLog10_0, '0']
- [blocks_throttle_0, '0', blocks_rms_xx_0, '0']
- [clenabled_clLog10_0, '0', blocks_abs_xx_1, '0']

metadata:
  file_format: 1
