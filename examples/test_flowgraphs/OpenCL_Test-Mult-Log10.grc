<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_opencl</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10.7622e6</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/opt/sdr/gnuradio/gnuradio_recordings/atsc/atsctest.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>clenabled_clLog10</key>
<param><key>id</key><value>clenabled_clLog10_0</value></param>
<param><key>setDebug</key><value>0</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>devices</key><value>1</value></param>
<param><key>openCLPlatform</key><value>1</value></param>
<param><key>platformId</key><value>0</value></param>
<param><key>k_val</key><value>0</value></param>
<param><key>n_val</key><value>20</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>avg</key><value>0.3</value></param>
<param><key>gui_hint</key><value>0,2,7,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value> Native</value></param>
<param><key>unit1</key><value>dB</value></param>
<param><key>label2</key><value>OpenCL Log10</value></param>
<param><key>max</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>Log10</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>GNURadio</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>CLEnabled</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_1</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>clenabled_clLog10_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_rms_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>clenabled_clLog10_0</source_block_id><sink_block_id>blocks_abs_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
