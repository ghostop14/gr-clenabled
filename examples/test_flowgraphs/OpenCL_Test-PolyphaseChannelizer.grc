options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: rate2
  id: variable
  parameters:
    value: (samp_rate/3)*1.5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: taplen
  id: variable
  parameters:
    value: len(taps)
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0,samp_rate,48e3,5e3)
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*3.14
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.1'
    offset: '-0.5'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_streams_1
  id: blocks_stream_to_streams
  parameters:
    num_streams: '3'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: clenabled_clPolyphaseChannelizer_0
  id: clenabled_clPolyphaseChannelizer
  parameters:
    buf_items: '6000'
    chmap: '[0,1,2]'
    deviceId: '0'
    devices: '1'
    ninputs_per_iter: '2'
    num_channels: '3'
    openCLPlatform: '4'
    platformId: '0'
    setDebug: '0'
    taps: taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[0,1,2]'
    nchans: '3'
    osr: '1.5'
    taps: taps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,3
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '.5'
    alpha2: '.5'
    bw: rate2
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,1
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '.5'
    alpha2: '.5'
    bw: rate2
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '.5'
    alpha2: '.5'
    bw: rate2
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,2,1,1
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_add_xx_0, '0', clenabled_clPolyphaseChannelizer_0, '0']
- [blocks_add_xx_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_stream_to_streams_1, '0', qtgui_freq_sink_x_0_1, '1']
- [blocks_stream_to_streams_1, '1', qtgui_freq_sink_x_0_2, '1']
- [blocks_stream_to_streams_1, '2', qtgui_freq_sink_x_0_0, '1']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [clenabled_clPolyphaseChannelizer_0, '0', blocks_stream_to_streams_1, '0']
- [pfb_channelizer_ccf_0, '0', qtgui_freq_sink_x_0_1, '0']
- [pfb_channelizer_ccf_0, '1', qtgui_freq_sink_x_0_2, '0']
- [pfb_channelizer_ccf_0, '2', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
