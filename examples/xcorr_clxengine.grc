options:
  parameters:
    generate_options: qt_gui
    id: xcorr_clxengine
    output_language: python
    title: OpenCL Correlation X Engine
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Center Frequency
    type: real
    value: 95.7e6
  states: {}
- name: chans
  id: variable
  parameters:
    value: '512'
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: complex
    vlen: chans
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: clenabled_clXEngine_0
  id: clenabled_clXEngine
  parameters:
    deviceId: '0'
    devices: '1'
    integration: '5'
    num_channels: '512'
    num_inputs: '4'
    openCLPlatform: '1'
    platformId: '0'
    polarization: '1'
    setDebug: 'False'
    type: Complex
  states: {}
- name: correctiq_correctiq_auto_0_0_0_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: correctiq_correctiq_auto_0_0_0_0_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: correctiq_correctiq_auto_0_0_0_0_0_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: correctiq_correctiq_auto_0_0_0_0_0_0_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,1,4
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-90'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: gain
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=1"'
    bb_gain0: gain
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=2"'
    bb_gain0: gain
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0_0_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=3"'
    bb_gain0: gain
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xcorrelate_triangular_to_full_0
  id: xcorrelate_triangular_to_full
  parameters:
    integration: '1024'
    num_inputs: '4'
    polarization: '1'
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_0_0_0, '0']
- [clenabled_clXEngine_0, xcorr, xcorrelate_triangular_to_full_0, triang]
- [correctiq_correctiq_auto_0_0_0_0, '0', blocks_stream_to_vector_0, '0']
- [correctiq_correctiq_auto_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [correctiq_correctiq_auto_0_0_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [correctiq_correctiq_auto_0_0_0_0_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [correctiq_correctiq_auto_0_0_0_0_0_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [fft_vxx_0, '0', blocks_null_sink_0, '0']
- [fft_vxx_0, '0', clenabled_clXEngine_0, '0']
- [fft_vxx_0_0, '0', blocks_null_sink_0, '1']
- [fft_vxx_0_0, '0', clenabled_clXEngine_0, '1']
- [fft_vxx_0_0_0, '0', blocks_null_sink_0, '2']
- [fft_vxx_0_0_0, '0', clenabled_clXEngine_0, '2']
- [fft_vxx_0_0_0_0, '0', blocks_null_sink_0, '3']
- [fft_vxx_0_0_0_0, '0', clenabled_clXEngine_0, '3']
- [rtlsdr_source_0, '0', correctiq_correctiq_auto_0_0_0_0, '0']
- [rtlsdr_source_0_0, '0', correctiq_correctiq_auto_0_0_0_0_0, '0']
- [rtlsdr_source_0_0_0, '0', correctiq_correctiq_auto_0_0_0_0_0_0, '0']
- [rtlsdr_source_0_0_0_0, '0', correctiq_correctiq_auto_0_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
