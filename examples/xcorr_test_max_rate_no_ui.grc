options:
  parameters:
    author: ghostop14
    generate_options: no_gui
    id: xcorr_test_max_rate_no_ui_opencl
    output_language: python
    realtime_scheduling: '1'
    title: Cross Correlation Test
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 95.7e6
  states: {}
- name: corr_frame_decim
  id: variable
  parameters:
    value: '200'
  states: {}
- name: corr_frame_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: delay_0
  id: variable
  parameters:
    comment: |-
      Must have a variable on the flowgraph
      for the "variable" field on the "Extract Delay" block.
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '32'
  states: {}
- name: lag
  id: variable
  parameters:
    value: '10'
  states: {}
- name: max_search
  id: variable
  parameters:
    value: '400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 46e6
  states: {}
- name: stage1_decimation
  id: variable
  parameters:
    value: int(samp_rate/500e3)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    comment: Quadrature rate is the input rate
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    affinity: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: lag
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_0
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: stage1_decimation
    type: complex
  states: {}
- name: clenabled_XCorrelate_0
  id: clenabled_XCorrelate
  parameters:
    async: 'True'
    decim_frames: '4'
    deviceId: '0'
    devices: '1'
    max_search_offset: '512'
    num_inputs: '2'
    openCLPlatform: '1'
    platformId: '0'
    setDebug: 'False'
    signal_length: '8192'
    type: float
  states: {}
- name: lfast_low_pass_filter_0_0
  id: lfast_low_pass_filter
  parameters:
    affinity: '1'
    beta: '6.76'
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    nthreads: '1'
    samp_rate: samp_rate
    type: ccc
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '0'
    ant0: RX2
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: '"num_recv_frames=128"'
    gain0: gain
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: xcorrelate_ExtractDelay_0
  id: xcorrelate_ExtractDelay
  parameters:
    index_to_extract: '0'
    lock: 'False'
    minCorrScore: '0.8'
    target: delay_0
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_complex_to_mag_0, '0', clenabled_XCorrelate_0, '0']
- [blocks_complex_to_mag_0_0, '0', clenabled_XCorrelate_0, '1']
- [blocks_delay_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_keep_one_in_n_0, '0', analog_wfm_rcv_0, '0']
- [clenabled_XCorrelate_0, corr, xcorrelate_ExtractDelay_0, corr]
- [lfast_low_pass_filter_0_0, '0', blocks_add_xx_0, '0']
- [lfast_low_pass_filter_0_0, '0', blocks_complex_to_mag_0, '0']
- [lfast_low_pass_filter_0_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', lfast_low_pass_filter_0_0, '0']

metadata:
  file_format: 1
